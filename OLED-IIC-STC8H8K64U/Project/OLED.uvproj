# Keil uVision project OLED.uvproj, settings and files
target FLASH (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Fwlib;..\Hardware\LED;..\Hardware\OLED;..\User;..\System\MyTimer;..\System\MyI2C;..\System\MyUART
  group FWLIB
    ../Fwlib/: delay.c GPIO.c timer.c I2C.c UART.C
  group SYSTEM
    ../System/MyTimer/: MyTimer.c
    ../System/MyI2C/: MyI2C.c
    ../System/MyUART/: MyUART.c
  group USER
    ../User/: main.c
  group HARDWARE
    ../Hardware/LED/: led.c
    ../Hardware/OLED/: screen.c oled.c
